#include "Duck.h"

const uint16_t Duck1Up[]=
{
	0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,22355,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,22355,22355,0,0,9293,9293,9293,9293,9293,0,0,0,0,0,0,0,0,0,22355,22355,22355,0,0,9293,9293,65535,65535,9293,0,0,0,0,0,0,0,0,22355,22355,22355,22355,0,0,9293,9293,9293,24327,24327,24327,0,0,0,0,0,0,0,22355,22355,22355,22355,0,0,9293,9293,9293,24327,24327,24327,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,0,65535,65535,65535,0,0,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,22355,0,0,0,0,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,22355,0,0,0,0,0,0,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
};
const uint16_t Duck1Flap[]=
{
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,9293,9293,9293,9293,9293,0,0,0,0,0,0,0,0,0,0,0,0,0,0,9293,9293,65535,65535,9293,0,0,0,0,0,0,0,0,0,0,0,0,0,0,9293,9293,9293,24327,24327,24327,0,0,0,0,0,0,0,0,0,0,0,0,0,9293,9293,9293,24327,24327,24327,0,0,0,0,0,0,37186,37186,37186,37186,37186,22355,0,65535,65535,65535,0,0,0,0,0,0,0,0,22355,37186,37186,37186,37186,37186,22355,0,0,0,0,0,0,0,0,0,0,22355,22355,22355,22355,37186,37186,37186,37186,22355,22355,22355,22355,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,37186,37186,37186,22355,22355,22355,22355,0,0,0,0,0,0,22355,22355,22355,22355,22355,22355,22355,37186,37186,22355,22355,22355,0,0,0,0,0,0,0,0,0,0,0,0,22355,22355,22355,37186,22355,22355,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
};

int RandMove(int min, int max) {
    // srand() should only be called ONCE globally, not inside this function
    return rand() % (max - min + 1) + min;
}

int i = 50;
int j = 50;
int toggle = 0;
int wallhit = 0;

void DuckMove(int x){


    static int randY = 50;
    static bool UpDown = false;
    static bool LeftRight = false;
    // printNumber(randY, 0, 140, RGBToWord(255,0,0), 0);

    if(j == 0){
        wallhit++;
    }

    switch(UpDown){
        case true:
            delay(10);
			if (toggle){
				putImage(j,i,19,13,Duck1Up,LeftRight,0);
                toggle = toggle - 1;
            }
			else {
				putImage(j,i,19,13,Duck1Flap,LeftRight,0);
				toggle = toggle + 1;
            }
            //putImage(j, i, 19, 13, Duck1Up, LeftRight, 0);
            i++;
            if(LeftRight == false){
                j++;
                if(j == x)
                    LeftRight = true;
            }
            if(LeftRight == true){
                j--;
                if(j == 0)
                    LeftRight = false;
            }
            if(i>=randY)
                UpDown = false;
            break;
        case false:
            delay(10);
			if (toggle){
				putImage(j,i,19,13,Duck1Up,LeftRight,0);
                toggle = toggle - 1;
            }
			else {
				putImage(j,i,19,13,Duck1Flap,LeftRight,0);
				toggle = toggle + 1;
            }
            //putImage(j, i, 19, 13, Duck1Up, LeftRight, 0);
            i--;
            if(LeftRight == false){
                j++;
                if(j == x)
                    LeftRight = true;
            }
            if(LeftRight == true){
                j--;
                if(j == 0)
                    LeftRight = false;
            }
            if(i <= 20)
                UpDown = true;
                randY = RandMove(20,120);
                if (randY == 0){
                    randY = RandMove(20,120);
                }
            break;     
    }
}
